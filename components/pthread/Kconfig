## components/pthread/Kconfig
```kconfig
menu "PThreads"
        config ENABLE_PTHREAD
            bool
            default y            
endmenu
```
